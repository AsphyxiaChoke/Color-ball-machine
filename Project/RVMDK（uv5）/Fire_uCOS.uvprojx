# Keil uVision project Fire_uCOS.uvprojx, settings and files
target Fire_uCOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Master_prg +hex
  AfterMake: fromelf.exe --bin -o ..\..\Output\Master_prg.bin ..\..\Output\Master_prg.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,CHECK_ERR
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\Libraries\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView;..\..\User\APP\inc;..\..\User\Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\Output\Master_prg.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c
  group USER_APP
    ../../User/: stm32h7xx_it.c
    ../../User/APP/: main.c var.c key_read.c dipsw.c arith.c GameSet.c MasterCmd.c MasterDriver.c ChildCmd.c Gameflow.c GameOption.c ZhuanQiuJi.c
  group BSP
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/: bsp.c cpu_bsp.c fmc.c gpio.c usart.c spi.c tim.c rng.c rtc.c
  group μC/CPU
    ../../User/uC-CPU/Cache/ARM/armv7m_generic_l1/: cpu_cache_armv7m_generic_l1.c
    ../../User/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group μC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../User/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group μC/OS-III Source
    ../../User/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group μC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group DOC
    ../../: 必读说明.txt
  group Driver
    ../../User/Drive/: spi_drive.c
